# Keil uVision project canopen.uvproj, settings and files
target Target 1 (166/167)
  device: XC164CS-16F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xC000-0xCFFF) IROM(0xC00000-0xC1FFFF) CLOCK(20000000) MOD167 MODV2
  output: canopen +hex
  group Dave Files
    ./: Start_V2.A66 MAIN.C CAN.C
  group src
    ./CANopen/src/: emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group driver
    ./CANopen/drivers/XC164/: can_xc164.c timer_xc164.c
  group objdict
    ./CANopen/: master.c
